File: g_plus_shield/v2/g_plus_shield_v2.brd (EAGLE design)
At the start: 81.3 x 66 mm, 23 parts, among them Q1 IRF840

Commit message: outstanding work
Routing:
- net LIMIT_Z: track 58.9 -> 61.1 mm
